options:
  parameters:
    generate_options: qt_gui
    id: basic_receive_flowgraph
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Frequency
    type: real
    value: 95.7e6
  states: {}
- name: gain
  id: variable
  parameters:
    comment: |-
      RX: 0-40 in 8 dB steps
      TX: 0-47 in 1 dB steps
    value: '24'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: correctiq_correctiq_0
  id: correctiq_correctiq
  parameters: {}
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    comment: HackRF Config
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,2,2
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-90'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 3,0,1,2
    int_min: '-90'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [correctiq_correctiq_0, '0', qtgui_freq_sink_x_0, '0']
- [correctiq_correctiq_0, '0', qtgui_waterfall_sink_x_0, '0']
- [osmosdr_source_0, '0', correctiq_correctiq_0, '0']

metadata:
  file_format: 1
