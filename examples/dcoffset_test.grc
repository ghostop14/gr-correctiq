options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: dcoffset_test
    output_language: python
  states: {}

blocks:
- name: amp_on
  id: variable
  parameters:
    value: '14'
  states: {}
- name: center_freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,1
    label: Center Frequency
    type: real
    value: 95.7e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: |-
      Hackrf:0-40 in 8 dB steps
      Airspy: 0-21
    gui_hint: 0,1,1,1
    label: Gain
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: imag
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    orient: Qt.Horizontal
    start: '-0.1'
    step: '0.0001'
    stop: '0.1'
    value: '-0.004100'
  states: {}
- name: real
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    orient: Qt.Horizontal
    start: '-0.1'
    step: '0.0001'
    stop: '0.1'
    value: '-0.011900'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_add_const_vxx_1_0
  id: blocks_add_const_vxx
  parameters:
    const: real + 1j * imag
    type: complex
  states: {}
- name: correctiq_correctiq_1
  id: correctiq_correctiq
  parameters: {}
  states: {}
- name: correctiq_correctiq_auto_0
  id: correctiq_correctiq_auto
  parameters:
    freq: center_freq
    gain: gain
    samp_rate: samp_rate
    syncWindow: '2'
  states: {}
- name: correctiq_correctiq_man_0
  id: correctiq_correctiq_man
  parameters:
    imag: imag
    real: real
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    comment: HackRF Config
    freq0: center_freq
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    label1: Add Const
    label2: Manual Offset
    label3: AutoSync Offset
    label4: CorrectIQ
    nconnections: '4'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Add Const I
    label2: Add Const Q
    label3: Manual CorrectIQ I
    label4: Manual CorrectIQ Q
    label5: Auto CorrectIQ I
    label6: Auto CorrectIQ Q
    label7: Full CorrectIQ I
    label8: Full CorrectIQ Q
    nconnections: '4'
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '0.01'
    ymin: '-0.01'
  states: {}

connections:
- [blocks_add_const_vxx_1_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_const_vxx_1_0, '0', qtgui_time_sink_x_0, '0']
- [correctiq_correctiq_1, '0', qtgui_freq_sink_x_0, '3']
- [correctiq_correctiq_1, '0', qtgui_time_sink_x_0, '3']
- [correctiq_correctiq_auto_0, '0', qtgui_freq_sink_x_0, '2']
- [correctiq_correctiq_auto_0, '0', qtgui_time_sink_x_0, '2']
- [correctiq_correctiq_man_0, '0', qtgui_freq_sink_x_0, '1']
- [correctiq_correctiq_man_0, '0', qtgui_time_sink_x_0, '1']
- [osmosdr_source_0, '0', blocks_add_const_vxx_1_0, '0']
- [osmosdr_source_0, '0', correctiq_correctiq_1, '0']
- [osmosdr_source_0, '0', correctiq_correctiq_auto_0, '0']
- [osmosdr_source_0, '0', correctiq_correctiq_man_0, '0']

metadata:
  file_format: 1
